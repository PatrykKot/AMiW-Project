# Keil uVision project AMiW.uvprojx, settings and files
target AMiW (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: AMiW
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.8.0\Drivers\BSP\Components\ft5336;C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.8.0\Drivers\BSP\STM32746G-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: stm32f7xx_it.c main.c stm32f7xx_hal_msp.c
  group BSP
    C:/Keil_v5/ARM/PACK/Keil/STM32F7xx_DFP/2.8.0/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F7xx_DFP/2.8.0/Drivers/BSP/Components/ft5336/: ft5336.c
software components: CMSIS:CORE 5.0.0, Device:STM32Cube Framework:Classic 1.1.2, Device:STM32Cube HAL:ADC 1.1.2, Device:STM32Cube HAL:Common 1.1.2, Device:STM32Cube HAL:Cortex 1.1.2, Device:STM32Cube HAL:DMA 1.1.2, Device:STM32Cube HAL:DMA2D 1.1.2, Device:STM32Cube HAL:GPIO 1.1.2, Device:STM32Cube HAL:I2C 1.1.2, Device:STM32Cube HAL:LTDC 1.1.2, Device:STM32Cube HAL:PWR 1.1.2, Device:STM32Cube HAL:RCC 1.1.2, Device:STM32Cube HAL:SDRAM 1.1.2, Device:STM32Cube HAL:SPI 1.1.2, Device:STM32Cube HAL:UART 1.1.2, Device:STM32Cube HAL:USART 1.1.2
