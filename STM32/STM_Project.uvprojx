# Keil uVision project STM_Project.uvprojx, settings and files
target STM32F746 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM_Project
  c flags: Optim=4
  c include: .\IncludeUser
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group SourceUser
    ./SourceUser/: main.c mcuConfig.c lcdLogger.c stm32f7xx_it.c
  group IncludeUser
    ./IncludeUser/: mcuConfig.h lcdLogger.h stm32f7xx_it.h
  group Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F7xx_DFP/2.8.0/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_lcd.c stm32746g_discovery.c stm32746g_discovery_ts.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F7xx_DFP/2.8.0/Drivers/BSP/Components/ft5336/: ft5336.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Drivers:SDRAM 1.1.1, CMSIS Driver:Ethernet MAC 1.3, CMSIS Driver:Ethernet PHY:LAN8742A 1.1, Device:STM32Cube Framework:Classic 1.1.2, Device:STM32Cube HAL:Common 1.1.2, Device:STM32Cube HAL:Cortex 1.1.2, Device:STM32Cube HAL:DMA 1.1.2, Device:STM32Cube HAL:DMA2D 1.1.2, Device:STM32Cube HAL:GPIO 1.1.2, Device:STM32Cube HAL:I2C 1.1.2, Device:STM32Cube HAL:LTDC 1.1.2, Device:STM32Cube HAL:PWR 1.1.2, Device:STM32Cube HAL:RCC 1.1.2, Device:STM32Cube HAL:SAI 1.1.2, Device:STM32Cube HAL:SDRAM 1.1.2, Device:STM32Cube HAL:TIM 1.1.2, Device:STM32Cube HAL:UART 1.1.2, Device:Startup 1.1.2
